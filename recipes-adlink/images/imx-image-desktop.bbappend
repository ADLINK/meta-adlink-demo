DEPENDS += "docker-datapart"

include datapart-conf.inc
