require dynamic-layers/ostree-var-path.inc

OSTREE_TMPFILES_CONF:sota = "L+ /var/rootdirs/opt/viv_samples - - - - /var/local/opt/viv_samples"
