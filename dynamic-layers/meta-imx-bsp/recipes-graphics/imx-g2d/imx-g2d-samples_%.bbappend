require dynamic-layers/ostree-var-path.inc

OSTREE_TMPFILES_CONF:sota = "L+ /var/rootdirs/opt/g2d_samples - - - - /var/local/opt/g2d_samples"
