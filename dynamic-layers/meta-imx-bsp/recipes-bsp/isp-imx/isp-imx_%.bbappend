require dynamic-layers/ostree-var-path.inc

OSTREE_TMPFILES_CONF:sota = "L+ /var/rootdirs/opt/imx8-isp - - - - /var/local/opt/imx8-isp"
