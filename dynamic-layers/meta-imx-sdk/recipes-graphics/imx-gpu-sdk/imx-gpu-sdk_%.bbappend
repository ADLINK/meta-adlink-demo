require dynamic-layers/ostree-var-path.inc

OSTREE_TMPFILES_CONF:sota = "L+ /var/rootdirs/opt/imx-gpu-sdk - - - - /var/local/opt/imx-gpu-sdk"
