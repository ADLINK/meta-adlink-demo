require dynamic-layers/ostree-var-path.inc

OSTREE_TMPFILES_CONF:sota = "L+ /var/rootdirs/opt/ic4-samples - - - - /var/local/opt/ic4-samples"
