require dynamic-layers/ostree-var-path.inc
OSTREE_TMPFILES_CONF:sota = "L+ /var/rootdirs/opt/gopoint-apps - - - - /var/local/opt/gopoint-apps"
