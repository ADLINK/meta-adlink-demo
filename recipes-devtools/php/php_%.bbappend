include ${@bb.utils.contains('IMAGE_FEATURES', 'lamp', 'server-setup.inc', '', d)}
