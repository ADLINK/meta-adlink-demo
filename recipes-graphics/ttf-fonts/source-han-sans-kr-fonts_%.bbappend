include ${@bb.utils.contains('DISTRO_CODENAME', 'scarthgap', 'ttf-cjk.inc', '', d)}
