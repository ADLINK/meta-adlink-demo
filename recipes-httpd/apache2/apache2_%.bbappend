include ${@bb.utils.contains('IMAGE_FEATURES', 'lamp', 'conf-setup.inc', '', d)}

