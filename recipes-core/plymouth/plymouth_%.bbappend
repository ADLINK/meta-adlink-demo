include ${@bb.utils.contains('IMAGE_FEATURES', 'fastboot', 'plymouth-logo.inc', '', d)}

