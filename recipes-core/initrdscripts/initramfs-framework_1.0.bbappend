include ${@bb.utils.contains('IMAGE_FEATURES', 'fastboot', 'framework-fastboot.inc', '', d)}

