include ${@bb.utils.contains('IMAGE_FEATURES', 'hidecursor', 'transparent-icon.inc', '', d)}
